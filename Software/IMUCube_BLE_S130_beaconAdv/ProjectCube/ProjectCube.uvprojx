# Keil uVision project ProjectCube.uvprojx, settings and files
target NRF51822 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51822
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51, BLE_STACK_SUPPORT_REQD, S130, SOFTDEVICE_PRESENT
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components\nRF_Drivers;..\Libraries\nRF_Components\nRF_Drivers\hal;..\Libraries\nRF_Components\nRF_Drivers\inc;..\Libraries\nRF_Components\nRF_Libraries\inc;..\Libraries\nRF_Components\nRF_SoftDevice\common;..\Libraries\nRF_Components\nRF_SoftDevice\s130;..\Libraries\nRF_Components\nRF_BLE\common;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf51.s system_nrf51.c
  group Driver
    ../Program/drivers/: nrf5x_delay.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c imuCube.c imuCube_bsp.c imuCube_it.c
  group Module
    ../Program/modules/: module_ws2812b.c
  group nRF_BLE
    ../Libraries/nRF_Components/nRF_BLE/common/: ble_advdata.c
  group nRF_Drivers
    ../Libraries/nRF_Components/nRF_Drivers/common/: nrf_drv_common.c
    ../Libraries/nRF_Components/nRF_Drivers/clock/: nrf_drv_clock.c
    ../Libraries/nRF_Components/nRF_Drivers/: nrf_drv_config.h
  group nRF_Libraries
    ../Libraries/nRF_Components/nRF_Libraries/util/: app_util_platform.c app_error.c app_error_weak.c
    ../Libraries/nRF_Components/nRF_Libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../Libraries/nRF_Components/nRF_SoftDevice/common/: softdevice_handler.c
