# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F103T8 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103T8 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c
    ../Program/: stm32f10x_conf.h
  group Driver
    ../Program/drivers/: stm32f1_delay.c stm32f1_usart.c stm32f1_spi.c
  group Program
    ../Program/: main.c imuCube.c imuCube_it.c
  group Module
    ../Program/modules/: module_serial.c module_mpu6500.c module_ws2812b.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c
