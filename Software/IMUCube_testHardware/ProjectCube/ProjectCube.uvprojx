# Keil uVision project ProjectCube.uvprojx, settings and files
target NRF51822 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51822
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components\nRF_Drivers;..\Libraries\nRF_Components\nRF_Drivers\hal;..\Libraries\nRF_Components\nRF_Drivers\inc;..\Libraries\nRF_Components\nRF_Libraries\inc;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf51.s system_nrf51.c
  group Driver
    ../Program/drivers/: nrf5x_delay.c nrf5x_adc.c nrf5x_spi.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c imuCube.c imuCube_bsp.c imuCube_it.c
  group Module
    ../Program/modules/: module_serial.c module_mpu9250.c module_ws2812b.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c
  group nRF_Drivers
    ../Libraries/nRF_Components/nRF_Drivers/common/: nrf_drv_common.c
    ../Libraries/nRF_Components/nRF_Drivers/clock/: nrf_drv_clock.c
    ../Libraries/nRF_Components/nRF_Drivers/adc/: nrf_drv_adc.c
    ../Libraries/nRF_Components/nRF_Drivers/uart/: nrf_drv_uart.c
    ../Libraries/nRF_Components/nRF_Drivers/spi_master/: nrf_drv_spi.c
    ../Libraries/nRF_Components/nRF_Drivers/: nrf_drv_config.h
  group nRF_Libraries
    ../Libraries/nRF_Components/nRF_Libraries/util/: app_util_platform.c
